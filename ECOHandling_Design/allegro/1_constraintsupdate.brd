# Allegro board 1_constraintsupdate.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VD6: length 107
  TOP w0.127: U5.K8 57.91,69.72 67.44,60.2 67.44,50.16 65.53,48.26 U6.8 62.87,48.26 62.36,47.75 62.36,45.34 64.01,43.69 65.02,43.69 67.31,41.4 67.31,33.53 65.53,31.75 U8.8 62.74,31.75 62.23,31.24 62.23,27.81 67.31,22.73 67.31,13.21 65.53,11.43 U9.8 54.23,11.43 v1(49.15,6.35)
  BOTTOM w0.127: R6.2 v1(49.15,6.35)
VD7: length 108.3
  TOP w0.127: v1(49.15,3.81) 55.5,10.16 U9.9 65.53,10.16 67.56,12.19 67.56,22.86 62.48,27.94 62.48,30.1 62.87,30.48 U8.9 65.53,30.48 67.56,32.51 67.56,41.53 65.15,43.94 64.13,43.94 62.61,45.47 62.61,46.61 62.99,46.99 U6.9 65.53,46.99 67.69,49.15 67.69,60.32 59.18,68.83 U5.K9
  BOTTOM w0.127: R10.2 v1(49.15,3.81)
VREF: length 35
  TOP w0.127: v1(102.62,4.95) 103.5,4.06 113.28,4.06 L5.1
  BOTTOM w0.127: L3.1 114.94,23.49 114.94,15.49 113.03,13.59 113.03,6.35 L5.1 ; R14.1 v1(102.62,4.95)
WAIT: length 0.8
  TOP w0.127: U5.J3 v1(51.03,82.65)
WSTAT: length 2.2
  TOP w0.127: U5.H4 v1(52.3,83.92) ; U6.11 v1(74.78,45.72)
N14843: length 3.2
  BOTTOM w0.127: C13.1 R12.1
N14849: length 3.2
  BOTTOM w0.127: C9.1 R8.1
N14853: length 3.2
  BOTTOM w0.127: C14.1 R13.1
N14855: length 3.2
  BOTTOM w0.127: C10.1 R9.1
N15143: length 3.2
  BOTTOM w0.127: C11.1 R10.1
N15151: length 3.2
  BOTTOM w0.127: C7.1 R6.1
N15155: length 3.2
  BOTTOM w0.127: C12.1 R11.1
N15161: length 3.2
  BOTTOM w0.127: C8.1 R7.1
N58063: length 5.7
  TOP w0.127: U8.19 U18.12
N58118: length 5.7
  TOP w0.127: U8.18 U18.13
N58173: length 5.7
  TOP w0.127: U8.17 U18.14
N58228: length 5.7
  TOP w0.127: U8.16 U18.15
N58283: length 5.7
  TOP w0.127: U8.15 U18.16
N58338: length 5.7
  TOP w0.127: U8.14 U18.17
N58393: length 5.7
  TOP w0.127: U8.13 U18.18
N58448: length 5.7
  TOP w0.127: U8.12 U18.19
N58834: length 6.4
  TOP w0.127: U9.19 U21.12
N58889: length 6.4
  TOP w0.127: U9.18 U21.13
N58944: length 6.4
  TOP w0.127: U9.17 U21.14
N58999: length 6.4
  TOP w0.127: U9.16 U21.15
N59054: length 6.4
  TOP w0.127: U9.15 U21.16
N59109: length 6.4
  TOP w0.127: U9.14 U21.17
N59164: length 6.4
  TOP w0.127: U9.13 U21.18
N59219: length 6.4
  TOP w0.127: U9.12 U21.19
N1626465: length 0.8
  TOP w0.127: U5.J7 v1(57.18,82.65)
